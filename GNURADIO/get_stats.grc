<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>analyze</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bandwith</value></param>
<param><key>value</key><value>samp_rate / 8</value></param>
<param><key>label</key><value>Reception bandwith (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>samp_rate / 100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>samp_rate / 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dc_offset_correction</value></param>
<param><key>value</key><value>samp_rate / 4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>433e6</value></param>
<param><key>label</key><value>Center frequency (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>3e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>(dc_offset_correction + bandwith)</value></param>
<param><key>low_cutoff_freq</key><value>(dc_offset_correction -bandwith)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>5e4</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/mpiuser/Descargas/LEER_-_Instructivo_de_la_Plantilla_LaTeX.pdf</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>150e-3</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>50e-3</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq + dc_offset_correction</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>stats_collector</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import time
import numpy as np
from gnuradio import gr

class blk (gr.sync_block):
    """
    Block to analyze the data on an already squared signal, comprised of 0's and 1's.
    """

    def __init__ (self
                , samp_rate = None):  # only default arguments here
        """
        Constructor.

        Args:
            samp_rate -&gt; Rate (in samples per second) that the flowgraph is working with,
                to deduce the frequency of the detected signal.
        """
        gr.sync_block.__init__(
            self,
            name = 'OOK statistics sink',
            in_sig = [np.float32],
            out_sig = []
        )

        self.time_delta = 0 # Timer to measure the time between edges

        # Max and min bursts, to print statistics
        self.max_burst = 0
        self.min_burst = np.inf

        # Lists to store timestamps of rising and falling edges
        self.rising_timestamps = []
        self.falling_timestamps = []

        # Last sample of the previous frame to handle the edge case of one fram ending
        # with 0 and the following starting with 1 (thus, not detecting a rising edge)
        self.previous_sample = 0

        # Counter to determine the end of a packet. If more than (2 * threshold) samples
        # are set to 0, the packet is done
        self.allzero_count = 0

        # ---- Statistics ----
        self.acc_mean = 0
        self.acc_mean_counter = 0 # Counter to calculate the accumulative mean

        self.short_bursts = {}
        self.long_bursts = {}

        self.short_median = None
        self.long_median = None

        self.samp_rate = samp_rate


    def calc_median (self, bursts):
        """
        Calculates the median of the given histogram

        Args:
            bursts -&gt; Dictionary with the counts of each burst length

        Returns:
            The median of the given histogram
        """
        median = 0
        acc = 0
        n = sum (bursts [k] for k in bursts) # Total number of samples
        stop = (n / 2.) # if n % 2 == 0 else (n + 1) / 2

        idx = 0
        keys = sorted (bursts)

        while acc &lt; stop:
            k = keys [idx]
            acc += bursts [k]

            if acc &gt; stop:
                median = k

            idx += 1

        # If it's an even number of elements, gets the average between the center values
        if (n % 2 == 0) and (idx &gt; 0) and (idx &lt; len (keys)):
            median = (keys [idx - 1] + keys [idx]) / 2

        return median


    def print_stats (self):
        """
        Prints the collected statistics
        """
        # Separator
        print ("*" * 30)

        # Prints min, max, and some other statistics
        print ("=&gt; General stats: ")
        print ("\t -&gt; Min burst: " + str (self.min_burst))
        print ("\t -&gt; Max burst: " + str (self.max_burst))

        print ("\t -&gt; Mean: " + str (self.acc_mean))

        # Long and short bursts
        print ("=&gt; Short bursts: ")
        print ("\t -&gt; Median: "
                + (str (self.short_median)
                    if self.short_median else
                    "-"
                )
        )
        print ("\t -&gt; Longer burst: "
                + (str (sorted (self.short_bursts).pop ())
                    if len (self.short_bursts) &gt; 0 else
                    "-"
                )
        )

        print ("=&gt; Long bursts: ")
        print ("\t -&gt; Median: "
                + (str (self.long_median)
                    if self.long_median else
                    "-"
                )
        )
        print ("\t -&gt; Shorter burst: "
                + (str (sorted (self.long_bursts) [0])
                    if len (self.long_bursts) &gt; 0 else
                    "-"
                )
        )

        # Period and frequency
        if self.samp_rate:

            period = ((self.short_median + self.long_median)
                        if (self.short_median and self.long_median) else
                        None
            )

            print ("=&gt; Signal period (median): "
                    + (str (period) if period else "N.A.")
                    + " samples "
                    + "(" + (str (self.samp_rate / float (period)) if period else "N.A.")
                    + " Hz)"
            )




    def work (self, input_items, *args, **kwargs):
        """
        Counts the different times measured between edges

        Args:
            input_items -&gt; Array with the items from the previous block

        Returns:
            The length of the processed input array
        """
        samples = input_items [0]
        diff = np.diff (samples)

        # Gets the indices of rising and falling edges
        falling = np.where (diff == -1)[0]
        rising = np.where (diff == 1)[0]

        # Takes care of an edge at the beginning
        if (self.previous_sample != samples [0]):
            if samples [0] == 0:
                # Falling edge
                falling = np.append (0, falling)
            else:
                # Raising edge
                rising = np.append (0, rising)

        self.previous_sample = samples [len (samples) - 1]

        # If the signal is flat, skips the rest of the processing
        if (len (rising) &lt;= 0
            and
            len (falling) &lt;= 0
        ):
            if samples [0] == 0:
                # All 0's
                self.allzero_count += len (samples)

                return len (samples)
            else:
                # All 1's
                self.allzero_count = 0
                self.time_delta += len (samples)
                return len (samples)
        else:
            # Prints the number of samples set to 0 (supposedly from the previous packet)
            if (self.allzero_count &gt; 0):
                print ("-" * 20)

                print ("Samples set to 0 (distance between packets): "
                        + str (self.allzero_count)
                )


            self.allzero_count = 0

            self.rising_timestamps += [ (x + self.time_delta) for x in rising ]
            self.falling_timestamps += [ (x + self.time_delta) for x in falling ]

            # Process the edges when there's at least one burst (rising + falling edges)
            if (len (self.rising_timestamps) == len (self.falling_timestamps)
                and
                len (self.rising_timestamps) &gt;= 1
                and
                len (self.falling_timestamps) &gt;= 1
            ):

                for rise, fall in zip (self.rising_timestamps, self.falling_timestamps):
                    diff = fall - rise

                    if diff &lt; self.min_burst:
                        self.min_burst = diff

                    if diff &gt; self.max_burst:
                        self.max_burst = diff

                    # Iterative mean, using the algorithm from Heiko Hoffman's web page
                    # http://www.heikohoffmann.de/htmlthesis/node134.html
                    #
                    # This avoids the possible overflow of storing the sum to calculate
                    # it the usual way (new_mean = (mean + x) / N)
                    self.acc_mean_counter += 1

                    self.acc_mean = (self.acc_mean
                                + (1. / self.acc_mean_counter)
                                * (diff - self.acc_mean)
                    )

                    # Waits until significant data is available to classify the bursts
                    if self.acc_mean_counter &gt; 10:

                        if diff &lt; self.acc_mean:
                            # Shorter than the average
                            if diff in self.short_bursts:
                                self.short_bursts [diff] += 1
                            else:
                                self.short_bursts [diff] = 1

                            self.short_median = self.calc_median (self.short_bursts)
                        else:
                            # Longer than the average
                            if diff in self.long_bursts:
                                self.long_bursts [diff] += 1
                            else:
                                self.long_bursts [diff] = 1

                            self.long_median = self.calc_median (self.long_bursts)


                    # Removes the processed timestamps
                    self.rising_timestamps.remove (rise)
                    self.falling_timestamps.remove (fall)

                self.print_stats ()

                # If both lists are empty, the counter can be resetted
                if (len (self.rising_timestamps) == 0
                    and
                    len (self.falling_timestamps) == 0
                ):
                    self.time_delta = 0

            self.time_delta += len (samples)

        return len (samples)
</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>label0</key><value>Original signal</value></param>
<param><key>label1</key><value>Squared signal</value></param>
<param><key>label2</key><value>Processed signal</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>stats_collector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
