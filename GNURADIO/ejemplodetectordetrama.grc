<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pi</value></param>
<param><key>value</key><value>3.141592654</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>analog_pll_refout_cc</key>
<param><key>id</key><value>analog_pll_refout_cc_0</value></param>
<param><key>w</key><value>pi/200</value></param>
<param><key>max_freq</key><value>2*pi*2.412e9</value></param>
<param><key>min_freq</key><value>2*pi*2.4e9</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>type</key><value>float</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>blks2_tcp_source</key>
<param><key>id</key><value>blks2_tcp_source_0</value></param>
<param><key>addr</key><value>192.168.0.176</value></param>
<param><key>server</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>port</key><value>80</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>16</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>64</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_1</value></param>
<param><key>length</key><value>48</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_plateau_detector_fb</key>
<param><key>id</key><value>blocks_plateau_detector_fb_0</value></param>
<param><key>max_len</key><value>2</value></param>
<param><key>threshold</key><value>637.5e-3</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>[0,pi]</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_0</value></param>
<param><key>lengthtagname</key><value>32</value></param>
<param><key>check</key><value>True</value></param>
<param><key>packed</key><value>True</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>len</key><value>11</value></param>
<param><key>mask</key><value>0x0</value></param>
<param><key>seed</key><value>0x5a8</value></param>
</block>
<block>
<key>digital_dxpsk_demod</key>
<param><key>id</key><value>digital_dxpsk_demod_0</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>log</key><value>False</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>sync_out</key><value>False</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
<param><key>type</key><value>dbpsk</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>1.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ted_gain</key><value>1.0</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>resamp_type</key><value>digital.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>0.045</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>ted_type</key><value>digital.TED_MUELLER_AND_MULLER</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>10e6</value></param>
<param><key>decim</key><value>480</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>0.5e6</value></param>
<param><key>win</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>analog_pll_refout_cc_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_tcp_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_tcp_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_tcp_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>blocks_plateau_detector_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_1</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_moving_average_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_plateau_detector_fb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>analog_pll_refout_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>blks2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>digital_crc32_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_dxpsk_demod_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>digital_dxpsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
